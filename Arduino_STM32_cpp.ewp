# IAR project Arduino_STM32_cpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; USE_IAR_STM32F0XX_KSK; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: ; ..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\Libraries\STM32F0xx_CPAL_Driver\inc; ..\Utilities\IAR_STM32F0xx_KSK; ..\Utilities\IAR_STM32F0xx_KSK\HD44780_Framework; ..\Utilities\IAR_STM32F0xx_KSK\Acc; Libraries; C:\Users\Pranav\Documents\IAR Embedded Workbench\IAR-STM32F051R8-SK\STM32F4_Libs\Libraries; C:\Users\Pranav\Documents\IAR Embedded Workbench\IAR-STM32F051R8-SK\STM32F4_Libs\Libraries\STM32F4xx_StdPeriph_Driver\inc; C:\Users\Pranav\Documents\IAR Embedded Workbench\IAR-STM32F051R8-SK\STM32F4_Libs\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Arduino_STM32_cpp.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: C:\Users\Pranav\Documents\IAR Embedded Workbench\IAR-STM32F051R8-SK\Arduino_STM32_cpp\config\stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 5.srec
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group EWARM
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group Libraries
    Libraries/: ardADC.cpp ardCOMP.cpp ardCRC.cpp ardDAC.cpp ardGPIO.cpp ardTIM.cpp ardUSART.cpp
  group STM32F0xx_StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group USB_dev
    Libraries/: stm32f0xx_usb.cpp stm32f0xx_usb.h USB.h usb_requests.cpp usb_standard.h
  group User
    ./: main.cpp stm32f0xx_it.cpp
